# Keil uVision project DFU.uvproj, settings and files
target USBFS_DFU (ARM-ADS)
  device: GD32F307ZG GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF)IROM(0x08000000-0x080FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4")
  output: HID_keyboard +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F30X_CL
  c misc: --c99
  c include: ..\..\..\..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\..\..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F30x_usbfs_driver\Include;..\inc;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: app.c usb_delay.c dfu_core.c dfu_mal.c flash_if.c gd32f30x_it.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_StdPeriph_Driver
    ../../../../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_pmu.c
  group GD32F30x_EVAL
    ../../../../../Utilities/: gd32f307c_eval.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group USB_Driver
    ../../../../../Firmware/GD32F30x_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group Doc
    ../: readme.txt

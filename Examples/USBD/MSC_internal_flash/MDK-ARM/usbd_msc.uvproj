# Keil uVision project usbd_msc.uvproj, settings and files
target USBD_MSC (ARM-ADS)
  device: GD32F303ZE GigaDevice
  cpu: IRAM(0x20000000-0x2000FFFF)IROM(0x08000000-0x0807FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4")
  output: MSC +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c misc: --c99
  c include: ..\..\..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\..\..\Firmware\GD32F30x_usbd_driver\Include;..\inc;..\..\..\..\Utilities;..\..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../src/: main.c msc_core.c flash_access.c bbb_scsi_driver.c gd32f30x_it.c
  group CMSIS
    ../../../../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../../../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_fmc.c
  group GD32F30x_EVAL
    ../../../../Utilities/: gd32f303e_eval.c
  group USBD_Drivers
    ../../../../Firmware/GD32F30x_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Doc
    ../: readme.txt
